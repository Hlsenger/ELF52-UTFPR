<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Exerc_16\Exerc_16.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exerc_17\Exerc_17.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exerc_18\Exerc_18.ewp</path>
    </project>
    <batchBuild />
</workspace>
