<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Laboratorio_05.ewp</path>
    </project>
    <batchBuild />
</workspace>
